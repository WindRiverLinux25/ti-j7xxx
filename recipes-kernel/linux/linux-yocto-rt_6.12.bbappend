require linux-yocto-ti-j7xxx.inc

KBRANCH:ti-j7 = "v6.12/standard/preempt-rt/ti-soc"

